// RC_Task.c �?Source-agnostic remote control ingestion task
// Glue among: bsp_dr16, bsp_vt03, lib_remote_control

#include "stm32h7xx_hal.h"
#include "FreeRTOS.h"
#include "task.h"
#include "usart.h"

#include "bsp_dr16.h"             // DR16_BSP_Init(), DR16_RegisterCallback(), DR16_FramerFeed()
#include "bsp_vt03.h"             // VT03_Init(), VT03_PollDec()
#include "lib_remote_control.h"   // RC_InputInit(), RC_UpdateFromDR16_Adapter(), RC_UpdateFromVT03(), RC_Tick()
#include "RC_Task.h"

#include "bsp_srn_log.h"

#ifndef RC_DR16_ISR_FIFO_SIZE
#define RC_DR16_ISR_FIFO_SIZE 256u
#endif

#ifndef RC_DR16_AUTO_SUSPEND
#define RC_DR16_AUTO_SUSPEND 1u
#endif

#ifndef RC_DR16_SUSPEND_DELAY_MS
#define RC_DR16_SUSPEND_DELAY_MS 3000u
#endif

#ifndef RC_VT03_START_DELAY_MS
#define RC_VT03_START_DELAY_MS 500u
#endif

#ifndef RC_VT03_START_RETRY_MS
#define RC_VT03_START_RETRY_MS 1000u
#endif

#ifndef RC_VT03_HEALTH_LOG_MS
#define RC_VT03_HEALTH_LOG_MS 1000u
#endif

static volatile uint8_t s_dr16_fifo[RC_DR16_ISR_FIFO_SIZE];
static volatile uint16_t s_dr16_head = 0;
static volatile uint16_t s_dr16_tail = 0;
static dr16_framer_t s_dr16_framer;
static uint8_t s_dr16_suspended = 0u;

volatile uint8_t rc_s0_state = RC_S0_STATE_DOWN;

static inline void dr16_fifo_push(uint8_t b)
{
    uint16_t next = (uint16_t)((s_dr16_tail + 1u) & (RC_DR16_ISR_FIFO_SIZE - 1u));
    if (next == s_dr16_head) return;
    s_dr16_fifo[s_dr16_tail] = b;
    s_dr16_tail = next;
}

static size_t dr16_fifo_pop(uint8_t* out, size_t max)
{
    size_t n = 0;
    while (n < max && s_dr16_head != s_dr16_tail) {
        out[n++] = s_dr16_fifo[s_dr16_head];
        s_dr16_head = (uint16_t)((s_dr16_head + 1u) & (RC_DR16_ISR_FIFO_SIZE - 1u));
    }
    return n;
}

static void dr16_suspend_rx(void)
{
    if (s_dr16_suspended) return;
    (void)HAL_UART_AbortReceive(&huart6);
    DR16_RegisterCallback(NULL);
    s_dr16_head = s_dr16_tail = 0u;
    DR16_FramerInit(&s_dr16_framer);
    s_dr16_suspended = 1u;
    LOGW("DR16 RX suspended (offline)");
}

static void dr16_isr_cb(const uint8_t* data, uint16_t len)
{
    if (!data || len == 0) return;
    for (uint16_t i = 0; i < len; ++i) {
        dr16_fifo_push(data[i]);
    }
}

static void rc_update_s0_state(uint32_t now_ms)
{
    RC_State rc;
    RC_GetSnapshot(&rc);
    uint8_t raw = RC_S0_STATE_DOWN;
    if (switch_is_mid(rc.rc.s[0])) {
        raw = RC_S0_STATE_MID;
    } else if (switch_is_up(rc.rc.s[0])) {
        raw = RC_S0_STATE_UP;
    }

    static uint8_t last_raw = RC_S0_STATE_DOWN;
    static uint32_t last_change_ms = 0;
    if (raw != last_raw) {
        last_raw = raw;
        last_change_ms = now_ms;
    }
    if ((now_ms - last_change_ms) >= RC_S0_STABLE_MS) {
        rc_s0_state = raw;
    }
}

void Start_RC_Task(void const * argument)
{
    (void)argument;

    /* 1) 统一输入管理�?*/
    RC_InputInit();
    RC_SetSourcePriority(RC_SRC_VT03, RC_SRC_DR16);   /* Default: VT03 > DR16 */
    /* 如需改阈值：
    // * RC_SetTimeouts(50 /*idle*/ //, 300 /*offline*/);
     //*/

    /* 2) 两个 BSP 上电（内部已�?UART To-Idle DMA �?ISR->FIFO�?*/
    DR16_FramerInit(&s_dr16_framer);
    DR16_BSP_Init();
    DR16_RegisterCallback(dr16_isr_cb);
    DR16_BSP_Start();


    const TickType_t period = pdMS_TO_TICKS(RC_TASK_POLL_PERIOD_MS);
    const uint32_t task_start_ms = HAL_GetTick();
    uint32_t dr16_last_online_ms = HAL_GetTick();
    uint32_t last_vt03_start_attempt_ms = 0u;
    uint32_t last_vt03_health_log_ms = task_start_ms;
    uint8_t vt03_start_attempted = 0u;
    uint8_t vt03_boot_logged = 0u;
    vt03_diag_t last_vt03_diag = {0};

    /* 变更检测：只在状态改变时打印 */
    uint8_t prev_dr16_on = 0;
    uint8_t prev_vt03_on = 0;
    uint8_t first_status_sampled = 0;

    for (;;)
    {
        const uint32_t now = HAL_GetTick();
        vt03_diag_t vt03_diag = {0};
        uint8_t vt03_started = 0u;

        if (VT03_ReadDiag(&vt03_diag)) {
            vt03_started = (vt03_diag.started != 0u) ? 1u : 0u;
        }

        if ((now - task_start_ms) >= RC_VT03_START_DELAY_MS) {
            if ((!vt03_start_attempted) ||
                (!vt03_started && ((now - last_vt03_start_attempt_ms) >= RC_VT03_START_RETRY_MS))) {
                if (!vt03_start_attempted) {
                    VT03_Init();
                    vt03_start_attempted = 1u;
                } else {
                    VT03_BSP_Start();
                }
                last_vt03_start_attempt_ms = now;
                if (VT03_ReadDiag(&vt03_diag)) {
                    vt03_started = (vt03_diag.started != 0u) ? 1u : 0u;
                    if (!vt03_boot_logged) {
                        vt03_boot_logged = 1u;
                        LOGI("[VT03][BOOT] boot_delay_ms=%lu flush_count=%lu stale_err_flags=0x%02lX start_ret=%lu",
                             (unsigned long)(now - task_start_ms),
                             (unsigned long)vt03_diag.rx_boot_flush_count,
                             (unsigned long)vt03_diag.rx_boot_stale_flags,
                             (unsigned long)vt03_diag.rx_boot_start_ret);
                    }
                }
            }
        }

        /* 3a) Poll DR16；如有新帧，交给 lib 做映射与仲裁 */
        if (!s_dr16_suspended) {
            uint8_t buf[64];
            size_t n = dr16_fifo_pop(buf, sizeof(buf));
            if (n > 0) {
                dr16_raw_t frames[2];
                size_t got = DR16_FramerFeed(&s_dr16_framer, buf, n, frames, 2);
                if (got > 0) {
                    dr16_dec_t d;
                    DR16_Decode18(frames[got - 1].b, &d);
                    RC_UpdateFromDR16_Adapter(&d, now);
                    rc_update_s0_state(now);
                    static uint32_t last_ch4_log_ms = 0;
                    if (now - last_ch4_log_ms >= 1000u) {
                        last_ch4_log_ms = now;
#if RC_TASK_LOG_DR16
                        const uint8_t* raw = frames[got - 1].b;
                        LOGI("DR16 ch0=%d ch1=%d ch2=%d ch3=%d ch4=%d (ch4=%d) s=%u,%u raw=%02X %02X %02X %02X %02X %02X %02X %02X %02X %02X %02X %02X %02X %02X %02X %02X %02X %02X",
                             d.ch[0], d.ch[1], d.ch[2], d.ch[3], d.ch[4], d.ch[4],
                             d.s1, d.s2,
                             raw[0], raw[1], raw[2], raw[3], raw[4], raw[5], raw[6], raw[7], raw[8],
                             raw[9], raw[10], raw[11], raw[12], raw[13], raw[14], raw[15], raw[16], raw[17]);
#endif
                    }
                }
            }
        }

        /* 3b) Poll VT03；如有新帧，交给 lib 做映射与仲裁 */
        vt03_dec_t v;
        if (vt03_started && VT03_PollDec(&v, now)) {
            RC_UpdateFromVT03(&v, now);
            rc_update_s0_state(now);
        }

        /* 4) 维护在线/空闲/阻塞状态（内部也会维护 active_src、sticks_idle 等） */
        RC_Tick(now);

        /* 5) 仅在在线状态发生变化时打印一次（避免刷屏�?*/
        RC_Status st = RC_GetStatus();
        const uint8_t dr16_on = st.dr16_online ? 1u : 0u;
        const uint8_t vt03_on = st.vt03_online ? 1u : 0u;

        if (dr16_on) {
            dr16_last_online_ms = now;
        }
#if RC_DR16_AUTO_SUSPEND
        if (!s_dr16_suspended &&
            !dr16_on &&
            (now - dr16_last_online_ms >= RC_DR16_SUSPEND_DELAY_MS)) {
            dr16_suspend_rx();
        }
#endif

        if (!first_status_sampled) {
            /* 第一次采样不打印，只建立基线 */
            prev_dr16_on = dr16_on;
            prev_vt03_on = vt03_on;
            first_status_sampled = 1;
        } else {
            if (dr16_on != prev_dr16_on) {

                prev_dr16_on = dr16_on;
            }
            if (vt03_on != prev_vt03_on) {

                prev_vt03_on = vt03_on;
            }
        }

        if ((now - last_vt03_health_log_ms) >= RC_VT03_HEALTH_LOG_MS) {
            last_vt03_health_log_ms = now;
            LOGI("[VT03][HEALTH] uart9_idle_evt_1s=%lu uart9_tc_evt_1s=%lu uart9_err_1s=%lu uart9_recover_1s=%lu vt03_started=%u vt03_online=%u",
                 (unsigned long)(vt03_diag.rx_evt_idle_count - last_vt03_diag.rx_evt_idle_count),
                 (unsigned long)(vt03_diag.rx_evt_tc_count - last_vt03_diag.rx_evt_tc_count),
                 (unsigned long)(vt03_diag.rx_hw_error_count - last_vt03_diag.rx_hw_error_count),
                 (unsigned long)(vt03_diag.rx_recover_count - last_vt03_diag.rx_recover_count),
                 (unsigned)vt03_started,
                 (unsigned)vt03_on);
            last_vt03_diag = vt03_diag;
        }

        vTaskDelay(period);
    }
}
